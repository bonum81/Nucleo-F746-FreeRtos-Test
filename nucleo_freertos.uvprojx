# Keil uVision project nucleo_freertos.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: nucleo_freertos
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER
  c include: .\FreeRTOS_inc;.\inc;.\SPL_inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./src/: main.c
  group freertos_src
    ./FreeRTOS_src/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_1.c
  group freertos_inc
    ./FreeRTOS_inc/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group LL_src
    ./SPL_src/: stm32f7xx_ll_exti.c stm32f7xx_ll_gpio.c stm32f7xx_ll_rcc.c stm32f7xx_ll_usart.c
  group LL_inc
    ./SPL_inc/: stm32f7xx_ll_exti.h stm32f7xx_ll_gpio.h stm32f7xx_ll_rcc.h stm32f7xx_ll_usart.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.2.2
